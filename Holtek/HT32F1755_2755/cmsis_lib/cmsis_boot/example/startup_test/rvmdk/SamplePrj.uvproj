# Keil uVision project SamplePrj.uvproj, settings and files
target sample_debug (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c flags: Optim=1
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\Include
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_ht32f175x_275x.c
  group src
    ../src/: main.c
  group startup
    ./: startup_ht32f175x_275x.s
target sample_release (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: as above
  output: SamplePrj
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
