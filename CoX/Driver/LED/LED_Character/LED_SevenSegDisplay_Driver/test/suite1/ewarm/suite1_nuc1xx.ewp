# IAR project suite1_nuc1xx.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm; xDEBUG; TEST_IO_PORT_BOARD=TEST_IO_PORT_NUC1XX
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_NUC1xx\libcox; ..\..\..\..\..\..\..\resource\testframe; ..\src; ..\..\..\lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: nuc1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group CoX/CoX_Driver/LED_SevenSegDisplay
    ../../../lib/: hw_sevenseg.h sevenseg.c sevenseg.h
  group CoX/CoX_Peripheral/inc
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xsysctl.h xtimer.h xuart.h
  group CoX/CoX_Peripheral/src
    ../../../../../../../CoX_Peripheral/CoX_Peripheral_NUC1xx/libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xtimer.c xuart.c
  group document
    ../../../../doc/txt/cox_peripheral_lib/: how to use COX.txt mainpage_en.txt
  group document/acmp
    ../../../../doc/txt/acmp/: nuc1xx_acmp_en.txt xacmp_en.txt
  group document/acmp/perl
    ../../../../doc/txt/acmp/perl/: xacmp.h.pl
  group document/adc
    ../../../../doc/txt/adc/: nuc1xx_adc_en.txt xadc_en.txt
  group document/adc/perl
    ../../../../doc/txt/adc/perl/: xadc.h.pl xadc_en.txt.pl
  group document/gpio
    ../../../../doc/txt/gpio/: nuvoton_gpio_en.txt xgpio_en.txt
  group document/gpio/perl
    ../../../../doc/txt/gpio/perl/: xgpio.h.pl
  group document/i2c
    ../../../../doc/txt/i2c/: nuveton_i2c_en.txt xi2c_en.txt
  group document/i2c/perl
    ../../../../doc/txt/i2c/perl/: xi2c.h.pl
  group document/rtc
    ../../../../doc/txt/rtc/: NUC1xx_rtc_en.txt xrtc_en.txt
  group document/rtc/perl
    ../../../../doc/txt/rtc/perl/: xrtc.h.pl
  group document/spi
    ../../../../doc/txt/spi/: nuc1xx_spi_en.txt xspi_en.txt
  group document/spi/perl
    ../../../../doc/txt/spi/perl/: xspi.h.pl
  group document/sysctl
    ../../../../doc/txt/sysctl/: nuc1xx_sysctl_en.txt xsysctl_en.txt
  group document/sysctl/perl
    ../../../../doc/txt/sysctl/perl/: xsysctl.h.pl
  group document/uart
    ../../../../doc/txt/uart/: group_relationship.txt NUC1xx_uart.txt UART.txt XUART.txt XUART_Apps.txt
  group document/uart/perl
    ../../../../doc/txt/uart/perl/: xuart.h.pl
  group document/watchdog
    ../../../../doc/txt/wdt/: nuvoton_wdt_en.txt xwdt_en.txt
  group document/watchdog/perl
    ../../../../doc/txt/wdt/perl/: xwatchdog.h.pl
  group document/xcore
    ../../../../doc/txt/core/: xcore_en.txt
  group ewarm
    ./: startup_ewarm.s
  group test/testcase
    ../src/: test1.c testcase.c testcase.h
  group test/testframe
    ../../../../../../../resource/testframe/: main.c test.c test.h testport.c
